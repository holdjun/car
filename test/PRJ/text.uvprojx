# Keil uVision project text.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: text +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\SCR\USER;..\SCR\STARTUP;..\SCR\FWLIB\GPIO;..\SCR\FWLIB\SYS;..\SCR\FWLIB\DMA;..\SCR\FWLIB\PDB;..\SCR\FWLIB\UART;..\SCR\FWLIB\WDOG;..\SCR\HARDWARE\LED;..\SCR\FWLIB\RTC;..\SCR\FWLIB\TSI;..\SCR\FWLIB\PIT;..\SCR\FWLIB\I2C;..\SCR\FWLIB\FTM;..\SCR\FWLIB\LPTM;..\SCR\FWLIB\SPI;..\SCR\HARDWARE\KEY;..\SCR\FWLIB\CAN;..\SCR\FWLIB\ADC;..\SCR\FWLIB\DAC;..\SCR\FWLIB\ENET;..\SCR\FWLIB\SD;..\SCR\FWLIB\FLASH;..\SCR\HARDWARE\SPILCD;..\SCR\HARDWARE\NRF2401;..\SCR\FWLIB\DELAY;..\SCR\FWLIB\oled;..\SCR\HARDWARE\DATA_SEND;..\SCR\HARDWARE\menu;..\SCR\HARDWARE\L3G4200D;..\SCR\FWLIB\dmacnt;..\SCR\FWLIB\CCD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group USER
    ../SCR/USER/: isr.c main.c
  group FWLIB
    ../SCR/FWLIB/GPIO/: gpio.c
    ../SCR/FWLIB/SYS/: sys.c
    ../SCR/FWLIB/DELAY/: delay.c
    ../SCR/FWLIB/ADC/: adc.c
    ../SCR/FWLIB/CAN/: can.c
    ../SCR/FWLIB/DAC/: dac.c
    ../SCR/FWLIB/DMA/: dma.c
    ../SCR/FWLIB/ENET/: enet.c
    ../SCR/FWLIB/FLASH/: flash.c
    ../SCR/FWLIB/FTM/: ftm.c
    ../SCR/FWLIB/I2C/: i2c.c
    ../SCR/FWLIB/LPTM/: lptm.c
    ../SCR/FWLIB/PDB/: pdb.c
    ../SCR/FWLIB/PIT/: pit.c
    ../SCR/FWLIB/RTC/: rtc.c
    ../SCR/FWLIB/SD/: sd.c
    ../SCR/FWLIB/SPI/: spi.c
    ../SCR/FWLIB/UART/: uart.c
    ../SCR/FWLIB/WDOG/: wdog.c
    ../SCR/FWLIB/oled/: oled.c
    ../SCR/FWLIB/dmacnt/: dmacnt.c
    ../SCR/FWLIB/CCD/: ccd.c
  group STARTUP
    ../SCR/STARTUP/: MK60DZ10.h startup_MK60DZ10.s system_MK60DZ10.c system_MK60DZ10.h
  group HARDWARE
    ../SCR/HARDWARE/KEY/: key.c
    ../SCR/HARDWARE/LED/: led.c
    ../SCR/HARDWARE/NRF2401/: nrf2401.c
    ../SCR/HARDWARE/SPILCD/: spilcd.c
    ../SCR/HARDWARE/DATA_SEND/: data_sent.c
    ../SCR/HARDWARE/L3G4200D/: L3G4200D.c
    ../SCR/HARDWARE/menu/: menu.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
