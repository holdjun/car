# Keil uVision project template.uvproj, settings and files
target Template (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: template
  c flags: Optim=1
  c include: ..\SRC\STARTUP;..\SRC\FWLIB\DELAY;..\SRC\FWLIB\GPIO;..\SRC\FWLIB\SYS;..\SRC\FWLIB\UART;..\SRC\FWLIB\WDOG;..\SRC\FWLIB\PIT;..\SRC\USER;..\SRC\HARDWARE\LED;..\SRC\\FWLIB\RTC;..\SRC\FWLIB\DMA;..\SRC\FWLIB\FTM;..\SRC\FWLIB\LPTM;..\SRC\FWLIB\ADC;..\SRC\FWLIB\DAC;..\SRC\FWLIB\SPI;..\SRC\HARDWARE\SPIFLASH;..\SRC\HARDWARE\SPILCD;..\SRC\FWLIB\I2C;..\SRC\FWLIB\PDB;..\SRC\HARDWARE\MMA845x;..\SRC\FWLIB\CAN;..\SRC\FWLIB\FLASH;..\SRC\FWLIB\SD;..\SRC\FWLIB\TSI;..\SRC\FWLIB\ENET;..\SRC\HARDWARE\oled;..\SRC\USER;..\..\2016-7-6\SRC\USER;..\SRC\HARDWARE\oled
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group STARTUP
    ../SRC/STARTUP/: system_MK60DZ10.c startup_MK60DZ10.s
  group USER
    ../SRC/USER/: main.c isr.c DataScope_DP.C
    ../../2016-7-6/SRC/USER/: dmacnt.c
  group FWLIB
    ../SRC/FWLIB/SYS/: sys.c
    ../SRC/FWLIB/DELAY/: delay.c
    ../SRC/FWLIB/DMA/: dma.c
    ../SRC/FWLIB/FTM/: ftm.c
    ../SRC/FWLIB/GPIO/: gpio.c
    ../SRC/FWLIB/LPTM/: lptm.c
    ../SRC/FWLIB/PIT/: pit.c
    ../SRC/FWLIB/RTC/: rtc.c
    ../SRC/FWLIB/UART/: uart.c
    ../SRC/FWLIB/WDOG/: wdog.c
    ../SRC/FWLIB/ADC/: adc.c
    ../SRC/FWLIB/PDB/: pdb.c
    ../SRC/FWLIB/DAC/: dac.c
    ../SRC/FWLIB/SPI/: spi.c
    ../SRC/FWLIB/I2C/: i2c.c
    ../SRC/FWLIB/CAN/: can.c
    ../SRC/FWLIB/FLASH/: flash.c
    ../SRC/FWLIB/SD/: sd.c
    ../SRC/FWLIB/TSI/: tsi.c
    ../SRC/FWLIB/ENET/: enet.c
  group HARDWARE
    ../SRC/HARDWARE/LED/: led.c
    ../SRC/HARDWARE/SPIFLASH/: spiflash.c
    ../SRC/HARDWARE/SPILCD/: spilcd.c
    ../SRC/HARDWARE/MMA845x/: mma845x.c
    ../SRC/HARDWARE/oled/: oled.c
  group Documentation
    ../SRC/USER/: Abstract.txt
